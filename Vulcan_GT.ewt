<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\APP\main.c</name>
    </file>
  </group>
  <group>
    <name>Modules</name>
    <group>
      <name>STM32_Lib</name>
      <group>
        <name>Drivers</name>
        <group>
          <name>CMSIS</name>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\CMSIS\Device\ST\STM32F2xx\Source\Templates\iar\startup_stm32f205xx.s</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\CMSIS\Device\ST\STM32F2xx\Source\Templates\system_stm32f2xx.c</name>
          </file>
        </group>
        <group>
          <name>STM32f2xx_HAL_Driver</name>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_can.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_cortex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_crc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_dac.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_dac_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_dma_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_flash_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_hash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_hcd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_i2s.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_irda.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_iwdg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_mmc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_nand.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_nor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_pccard.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_pcd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_pcd_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_pwr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_pwr_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_rcc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_rcc_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_rtc_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_sd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_smartcard.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_sram.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_tim.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_tim_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_usart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_wwdg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_fsmc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_sdmmc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_usb.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>Middlewares</name>
        <group>
          <name>FatFs</name>
          <file>
            <name>$PROJ_DIR$\Modules\STM32_Lib\Middlewares\Third_Party\FatFs\src\ff.c</name>
          </file>
        </group>
        <group>
          <name>STM32_USBH_Library</name>
          <group>
            <name>Class</name>
            <group>
              <name>MSC</name>
              <file>
                <name>$PROJ_DIR$\Modules\STM32_Lib\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\Modules\STM32_Lib\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_bot.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\Modules\STM32_Lib\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_scsi.c</name>
              </file>
            </group>
          </group>
          <group>
            <name>Core</name>
            <file>
              <name>$PROJ_DIR$\Modules\STM32_Lib\Middlewares\ST\STM32_USB_Host_Library\Core\Src\usbh_core.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Modules\STM32_Lib\Middlewares\ST\STM32_USB_Host_Library\Core\Src\usbh_ctlreq.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Modules\STM32_Lib\Middlewares\ST\STM32_USB_Host_Library\Core\Src\usbh_ioreq.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\Modules\STM32_Lib\Middlewares\ST\STM32_USB_Host_Library\Core\Src\usbh_pipes.c</name>
            </file>
          </group>
        </group>
      </group>
      <file>
        <name>$PROJ_DIR$\Modules\STM32_Lib\stm32f2xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Modules\STM32_Lib\stm32f2xx_it.c</name>
      </file>
    </group>
  </group>
</project>


