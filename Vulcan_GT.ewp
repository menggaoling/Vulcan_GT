# IAR project Vulcan_GT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205VE ST STM32F205VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_USB_FS; STM32F205xx
  ICCARM.CCIncludePath2: APP; Modules\STM32_Lib; Modules\STM32_Lib\Drivers\CMSIS\Device\ST\STM32F2xx\Include; Modules\STM32_Lib\Drivers\CMSIS\Include; Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Inc; Modules\STM32_Lib\Drivers\STM32F2xx_HAL_Driver\Inc\Legacy; Modules\STM32_Lib\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; Modules\STM32_Lib\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; Modules\STM32_Lib\Middlewares\Third_Party\FatFs\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Vulcan_GT_V1_001.bin
  ILINK.IlinkOutputFile: Vulcan_GT.out
  ILINK.IlinkIcfFile: Config\stm32f205xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: main.c
  group Modules/STM32_Lib
    Modules/STM32_Lib/: stm32f2xx_hal_msp.c stm32f2xx_it.c
  group Modules/STM32_Lib/Drivers/CMSIS
    Modules/STM32_Lib/Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f205xx.s
    Modules/STM32_Lib/Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Modules/STM32_Lib/Drivers/STM32f2xx_HAL_Driver
    Modules/STM32_Lib/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_can.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hash.c stm32f2xx_hal_hcd.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_irda.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_mmc.c stm32f2xx_hal_nand.c stm32f2xx_hal_nor.c stm32f2xx_hal_pccard.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_usart.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_fsmc.c stm32f2xx_ll_sdmmc.c stm32f2xx_ll_usb.c
  group Modules/STM32_Lib/Middlewares/FatFs
    Modules/STM32_Lib/Middlewares/Third_Party/FatFs/src/: ff.c
  group Modules/STM32_Lib/Middlewares/STM32_USBH_Library/Class/MSC
    Modules/STM32_Lib/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Modules/STM32_Lib/Middlewares/STM32_USBH_Library/Core
    Modules/STM32_Lib/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
